<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>file_demod</value></param>
<param><key>author</key><value>Garrett Vanhoy</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>File Demodulator</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>const</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/gvanhoy/gr-physec/apps/sources/bpsk2qam16.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>const.bits_per_symbol()</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>constellation</key><value>const</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
